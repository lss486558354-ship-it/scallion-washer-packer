# Keil uVision project BH-F103.uvprojx, settings and files
target USART_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART_FreeRTOS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\protocol;..\..\User\stepper;..\..\User\dc_motor;..\..\User\tick;..\..\User\sensor;..\..\User\limit_switch;..\..\User\servo;..\..\User\motor;..\..\User\gpio;..\..\User\freertos;..\..\deploy;..\..\Doc;..\..\Libraries;..\..\User\atim;..\..\User\relay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h device.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/usart/: bsp_usart_obj.c
    ../../User/protocol/: protocol.c process_control.c
    ../../User/stepper/: bsp_stepper.c
    ../../User/dc_motor/: bsp_dc_motor_obj.c
    ../../User/tick/: bsp_tick.c
    ../../User/sensor/: bsp_sensor_obj.c bsp_mpu6050.c bsp_hx711.c
    ../../User/limit_switch/: bsp_limit_switch.c
    ../../User/servo/: bsp_servo_obj.c bsp_servo_serial.c
    ../../User/freertos/: freertos_app.c
    ../../User/relay/: bsp_relay.c
    ../../User/atim/: atim.c
